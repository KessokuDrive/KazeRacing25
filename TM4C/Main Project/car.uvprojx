# Keil uVision project car.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: car
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk,PART_TM4C123GH6PM
  c include: .\user;..\lib;..\lib\driverlib;..\lib\inc;..\lib\utils;.\user
  asm define: rvmdk,PART_TM4C123GH6PM
  asm include: .\user;..\lib;..\lib\driverlib;..\lib\inc;..\lib\utils
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group lib
    ../lib/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group user
    ./user/: main.c pwm_output.c pwm_output.h rc_input.c rc_input.h manual.c manual.h auto.c auto.h control.c control.h data.c data.h jetson_control.c uartstdio.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
